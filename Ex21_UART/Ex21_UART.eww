<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Ex21_UART.ewp</path>
    </project>
    <batchBuild />
</workspace>
